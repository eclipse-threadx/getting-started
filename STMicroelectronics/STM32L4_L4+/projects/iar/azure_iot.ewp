# IAR project azure_iot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4S5VI ST STM32L4S5VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TX_INCLUDE_USER_DEFINE_FILE; NX_INCLUDE_USER_DEFINE_FILE; NX_AZURE_DISABLE_IOT_SECURITY_MODULE; STM32L475xx; USE_HAL_DRIVER; USE_STM32L475E_IOT01; JSMN_HEADER
  ICCARM.CCIncludePath2: ..\..\lib\threadx; ..\..\..\..\core\lib\threadx\common\inc; ..\..\..\..\core\lib\threadx\ports\cortex_m4\iar\inc; ..\..\lib\netxduo; ..\..\lib\netxduo\ports\cortex_m4\iar\inc; ..\..\lib\netxduo\common; ..\..\lib\netxduo\crypto_libraries\inc; ..\..\lib\netxduo\nx_secure\inc; ..\..\lib\netxduo\nx_secure\ports; ..\..\lib\netxduo\addons\dns; ..\..\lib\netxduo\addons\mqtt; ..\..\lib\netxduo\addons\sntp; ..\..\lib\netx_driver\src; ..\..\..\..\core\lib\azure-iot-preview\nx_cloud; ..\..\..\..\core\lib\azure-iot-preview\azure_iot; ..\..\..\..\core\lib\azure-iot-preview\azure_iot\azure-sdk-for-c\sdk\inc; ..\..\lib\stm32cubel4\config; ..\..\lib\stm32cubel4\Drivers\BSP\B-L475E-IOT01; ..\..\lib\stm32cubel4\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\lib\stm32cubel4\Drivers\CMSIS\Include; ..\..\lib\stm32cubel4\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\core\src; ..\..\..\..\core\src\azure_iot_mqtt; ..\..\..\..\core\src\azure_iot_nx; ..\..\..\..\core\lib\jsmn\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: azure_iot.bin
  ILINK.IlinkOutputFile: azure_iot.out
  ILINK.IlinkIcfFile: ..\..\app\startup\iar\stm32l4s5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; TX_INCLUDE_USER_DEFINE_FILE; NX_INCLUDE_USER_DEFINE_FILE; NX_AZURE_DISABLE_IOT_SECURITY_MODULE; STM32L475xx; USE_HAL_DRIVER; USE_STM32L475E_IOT01; JSMN_HEADER
  ICCARM.CCIncludePath2: ..\..\lib\threadx; ..\..\..\..\core\lib\threadx\common\inc; ..\..\..\..\core\lib\threadx\ports\cortex_m4\iar\inc; ..\..\lib\netxduo; ..\..\lib\netxduo\ports\cortex_m4\iar\inc; ..\..\lib\netxduo\src; ..\..\lib\netxduo\addons\dns; ..\..\lib\netxduo\addons\mqtt; ..\..\lib\netxduo\addons\sntp; ..\..\lib\netx_driver\src; ..\..\..\..\core\lib\azure-iot-preview\nx_cloud; ..\..\..\..\core\lib\azure-iot-preview\azure_iot; ..\..\..\..\core\lib\azure-iot-preview\azure_iot\azure-sdk-for-c\sdk\inc; ..\..\lib\stm32cubel4\config; ..\..\lib\stm32cubel4\Drivers\BSP\B-L475E-IOT01; ..\..\lib\stm32cubel4\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\lib\stm32cubel4\Drivers\CMSIS\Include; ..\..\lib\stm32cubel4\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\core\src; ..\..\..\..\core\src\azure_iot_mqtt; ..\..\..\..\core\src\azure_iot_nx; ..\..\..\..\core\lib\jsmn\src
  ICCARM.CCOptLevel: 3
  group app
    ../../app/: azure_config.h board_init.c board_init.h CMakeLists.txt console.c main.c mqtt.c mqtt.h nx_client.c nx_client.h stm_networking.c stm_networking.h
  group app/startup
    ../../app/startup/iar/: startup_stm32l4s5xx.s tx_initialize_low_level.s
  group app/stm32cube4
    ../../app/stm32cubel4/: stm32l4xx_hal_msp.c stm32l4xx_it.c stm32l4xx_it.h
  group core
    ../../../../core/src/: azure_iot_cert.c azure_iot_cert.h azure_iot_ciphersuites.c azure_iot_ciphersuites.h cmsis_utils.h json_utils.c json_utils.h sntp_client.c sntp_client.h
  group core/azure_iot_mqtt
    ../../../../core/src/azure_iot_mqtt/: azure_iot_dps_mqtt.c azure_iot_dps_mqtt.h azure_iot_mqtt.c azure_iot_mqtt.h hmac_sha256.c hmac_sha256.h sas_token.c sas_token.h sha256.c sha256.h
  group core/azure_iot_nx
    ../../../../core/src/azure_iot_nx/: azure_iot_nx_client.c azure_iot_nx_client.h nx_azure_iot_pnp_helpers.c nx_azure_iot_pnp_helpers.h
  group lib/jsmn
    ../../../../core/lib/jsmn/: jsmn.c
  group lib/netx_driver
    ../../lib/netx_driver/src/: es_wifi.c es_wifi.h es_wifi_conf.h es_wifi_io.c es_wifi_io.h nx_wifi.c wifi.c wifi.h
  group lib/netxduo
    ../../lib/netxduo/: nx_user.h
  group lib/netxduo/addons/azure_iot
    ../../../../core/lib/azure-iot-preview/azure_iot/: nx_azure_iot.c nx_azure_iot.h nx_azure_iot_hub_client.c nx_azure_iot_hub_client.h nx_azure_iot_provisioning_client.c nx_azure_iot_provisioning_client.h
  group lib/netxduo/addons/azure_iot/azure-sdk-for-c/core
    ../../../../core/lib/azure-iot-preview/azure_iot/azure-sdk-for-c/sdk/src/azure/core/: az_json_reader.c az_json_token.c az_json_writer.c az_log.c az_precondition.c az_span.c
  group lib/netxduo/addons/azure_iot/azure-sdk-for-c/iot
    ../../../../core/lib/azure-iot-preview/azure_iot/azure-sdk-for-c/sdk/src/azure/iot/: az_iot_common.c az_iot_hub_client.c az_iot_hub_client_c2d.c az_iot_hub_client_methods.c az_iot_hub_client_sas.c az_iot_hub_client_telemetry.c az_iot_hub_client_twin.c az_iot_provisioning_client.c az_iot_provisioning_client_sas.c
  group lib/netxduo/addons/cloud
    ../../../../core/lib/azure-iot-preview/nx_cloud/: nx_cloud.c nx_cloud.h
  group lib/netxduo/addons/dns
    ../../lib/netxduo/addons/dns/: nxd_dns.c nxd_dns.h
  group lib/netxduo/addons/mqtt
    ../../lib/netxduo/addons/mqtt/: nxd_mqtt_client.c nxd_mqtt_client.h
  group lib/netxduo/addons/sntp
    ../../lib/netxduo/addons/sntp/: nxd_sntp_client.c nxd_sntp_client.h
  group lib/netxduo/common
    ../../lib/netxduo/common/: nx_api.h nx_ip.h nx_ip_create.c nx_ip_delete.c nx_ip_initialize.c nx_ipv4.h nx_ipv6.h nx_packet.h nx_packet_allocate.c nx_packet_copy.c nx_packet_data_adjust.c nx_packet_data_append.c nx_packet_data_extract_offset.c nx_packet_data_retrieve.c nx_packet_debug_info_get.c nx_packet_length_get.c nx_packet_pool_cleanup.c nx_packet_pool_create.c nx_packet_pool_delete.c nx_packet_pool_info_get.c nx_packet_pool_initialize.c nx_packet_pool_low_watermark_set.c nx_packet_release.c nx_packet_transmit_release.c nx_system.h nx_system_initialize.c nx_tcp.h nx_tcp_client_socket_bind.c nx_tcp_client_socket_connect.c nx_tcp_client_socket_unbind.c nx_tcp_enable.c nx_tcp_free_port_find.c nx_tcp_initialize.c nx_tcp_socket_block_cleanup.c nx_tcp_socket_create.c nx_tcp_socket_delete.c nx_tcp_socket_disconnect.c nx_tcp_socket_establish_notify.c nx_tcp_socket_receive.c nx_tcp_socket_receive_notify.c nx_tcp_socket_send.c nx_tcp_socket_state_wait.c nx_udp.h nx_udp_enable.c nx_udp_free_port_find.c nx_udp_socket_bind.c nx_udp_socket_create.c nx_udp_socket_delete.c nx_udp_socket_receive.c nx_udp_socket_receive_notify.c nx_udp_socket_send.c nx_udp_socket_unbind.c nx_utility.c nx_wifi.h nxd_tcp_client_socket_connect.c nxd_udp_socket_send.c nxde_tcp_client_socket_connect.c nxde_tcp_socket_peer_info_get.c nxde_udp_socket_send.c nxe_ip_create.c nxe_ip_delete.c nxe_packet_allocate.c nxe_packet_copy.c nxe_packet_data_append.c nxe_packet_data_extract_offset.c nxe_packet_data_retrieve.c nxe_packet_length_get.c nxe_packet_pool_create.c nxe_packet_pool_delete.c nxe_packet_pool_info_get.c nxe_packet_pool_low_watermark_set.c nxe_packet_release.c nxe_packet_transmit_release.c nxe_tcp_client_socket_bind.c nxe_tcp_client_socket_connect.c nxe_tcp_client_socket_unbind.c nxe_tcp_enable.c nxe_tcp_socket_create.c nxe_tcp_socket_delete.c nxe_tcp_socket_disconnect.c nxe_tcp_socket_establish_notify.c nxe_tcp_socket_receive.c nxe_tcp_socket_receive_notify.c nxe_tcp_socket_send.c nxe_tcp_socket_state_wait.c nxe_udp_enable.c nxe_udp_socket_bind.c nxe_udp_socket_create.c nxe_udp_socket_delete.c nxe_udp_socket_receive.c nxe_udp_socket_receive_notify.c nxe_udp_socket_send.c nxe_udp_socket_unbind.c
  group lib/netxduo/crypto_libraries/inc
    ../../lib/netxduo/crypto_libraries/inc/: nx_crypto.h nx_crypto_3des.h nx_crypto_aes.h nx_crypto_cbc.h nx_crypto_ccm.h nx_crypto_const.h nx_crypto_ctr.h nx_crypto_des.h nx_crypto_dh.h nx_crypto_drbg.h nx_crypto_ec.h nx_crypto_ecdh.h nx_crypto_ecdsa.h nx_crypto_ecjpake.h nx_crypto_gcm.h nx_crypto_hkdf.h nx_crypto_hmac.h nx_crypto_hmac_md5.h nx_crypto_hmac_sha1.h nx_crypto_hmac_sha2.h nx_crypto_hmac_sha5.h nx_crypto_huge_number.h nx_crypto_md5.h nx_crypto_method_self_test.h nx_crypto_null.h nx_crypto_phash.h nx_crypto_pkcs1_v1.5.h nx_crypto_rsa.h nx_crypto_sha1.h nx_crypto_sha2.h nx_crypto_sha5.h nx_crypto_tls_prf_1.h nx_crypto_tls_prf_sha256.h nx_crypto_tls_prf_sha384.h nx_crypto_tls_prf_sha512.h nx_crypto_xcbc_mac.h
  group lib/netxduo/crypto_libraries/src
    ../../lib/netxduo/crypto_libraries/src/: nx_crypto_3des.c nx_crypto_aes.c nx_crypto_cbc.c nx_crypto_ccm.c nx_crypto_ctr.c nx_crypto_des.c nx_crypto_dh.c nx_crypto_drbg.c nx_crypto_ec.c nx_crypto_ec_secp192r1_fixed_points.c nx_crypto_ec_secp224r1_fixed_points.c nx_crypto_ec_secp256r1_fixed_points.c nx_crypto_ec_secp384r1_fixed_points.c nx_crypto_ec_secp521r1_fixed_points.c nx_crypto_ecdh.c nx_crypto_ecdsa.c nx_crypto_ecjpake.c nx_crypto_gcm.c nx_crypto_generic_ciphersuites.c nx_crypto_hkdf.c nx_crypto_hmac.c nx_crypto_hmac_md5.c nx_crypto_hmac_sha1.c nx_crypto_hmac_sha2.c nx_crypto_hmac_sha5.c nx_crypto_huge_number.c nx_crypto_huge_number_extended.c nx_crypto_initialize.c nx_crypto_md5.c nx_crypto_method_self_test.c nx_crypto_method_self_test_3des.c nx_crypto_method_self_test_aes.c nx_crypto_method_self_test_des.c nx_crypto_method_self_test_drbg.c nx_crypto_method_self_test_ecdh.c nx_crypto_method_self_test_ecdsa.c nx_crypto_method_self_test_hmac_md5.c nx_crypto_method_self_test_hmac_sha.c nx_crypto_method_self_test_md5.c nx_crypto_method_self_test_pkcs1.c nx_crypto_method_self_test_prf.c nx_crypto_method_self_test_rsa.c nx_crypto_method_self_test_sha.c nx_crypto_methods.c nx_crypto_module_start.c nx_crypto_null_cipher.c nx_crypto_phash.c nx_crypto_pkcs1_v1.5.c nx_crypto_rsa.c nx_crypto_sha1.c nx_crypto_sha2.c nx_crypto_sha5.c nx_crypto_tls_prf_1.c nx_crypto_tls_prf_sha256.c nx_crypto_tls_prf_sha384.c nx_crypto_tls_prf_sha512.c nx_crypto_xcbc_mac.c
  group lib/netxduo/nx_secure/inc
    ../../lib/netxduo/nx_secure/inc/: nx_secure_crypto_table_self_test.h nx_secure_dtls.h nx_secure_dtls_api.h nx_secure_tls.h nx_secure_tls_api.h nx_secure_user_sample.h nx_secure_x509.h
  group lib/netxduo/nx_secure/ports
    ../../lib/netxduo/nx_secure/ports/: nx_secure_port.h
  group lib/netxduo/nx_secure/src
    ../../lib/netxduo/nx_secure/src/: nx_secure_crypto_method_self_test_3des.c nx_secure_crypto_method_self_test_aes.c nx_secure_crypto_method_self_test_des.c nx_secure_crypto_method_self_test_hmac_md5.c nx_secure_crypto_method_self_test_hmac_sha.c nx_secure_crypto_method_self_test_md5.c nx_secure_crypto_method_self_test_prf.c nx_secure_crypto_method_self_test_rsa.c nx_secure_crypto_method_self_test_sha.c nx_secure_crypto_rng_self_test.c nx_secure_crypto_table_self_test.c nx_secure_dtls_allocate_handshake_packet.c nx_secure_dtls_client_handshake.c nx_secure_dtls_client_protocol_version_override.c nx_secure_dtls_client_session_start.c nx_secure_dtls_ecc_initialize.c nx_secure_dtls_hash_record.c nx_secure_dtls_initialize.c nx_secure_dtls_packet_allocate.c nx_secure_dtls_process_clienthello.c nx_secure_dtls_process_handshake_header.c nx_secure_dtls_process_header.c nx_secure_dtls_process_helloverifyrequest.c nx_secure_dtls_process_record.c nx_secure_dtls_psk_add.c nx_secure_dtls_receive_callback.c nx_secure_dtls_retransmit.c nx_secure_dtls_retransmit_queue_flush.c nx_secure_dtls_send_clienthello.c nx_secure_dtls_send_handshake_record.c nx_secure_dtls_send_helloverifyrequest.c nx_secure_dtls_send_record.c nx_secure_dtls_send_serverhello.c nx_secure_dtls_server_create.c nx_secure_dtls_server_delete.c nx_secure_dtls_server_ecc_initialize.c nx_secure_dtls_server_handshake.c nx_secure_dtls_server_local_certificate_add.c nx_secure_dtls_server_local_certificate_remove.c nx_secure_dtls_server_notify_set.c nx_secure_dtls_server_protocol_version_override.c nx_secure_dtls_server_psk_add.c nx_secure_dtls_server_session_send.c nx_secure_dtls_server_session_start.c nx_secure_dtls_server_start.c nx_secure_dtls_server_stop.c nx_secure_dtls_server_trusted_certificate_add.c nx_secure_dtls_server_trusted_certificate_remove.c nx_secure_dtls_server_x509_client_verify_configure.c nx_secure_dtls_server_x509_client_verify_disable.c nx_secure_dtls_session_cache.c nx_secure_dtls_session_client_info_get.c nx_secure_dtls_session_create.c nx_secure_dtls_session_delete.c nx_secure_dtls_session_end.c nx_secure_dtls_session_local_certificate_add.c nx_secure_dtls_session_local_certificate_remove.c nx_secure_dtls_session_receive.c nx_secure_dtls_session_reset.c nx_secure_dtls_session_send.c nx_secure_dtls_session_start.c nx_secure_dtls_session_trusted_certificate_add.c nx_secure_dtls_session_trusted_certificate_remove.c nx_secure_dtls_verify_mac.c nx_secure_module_hash_compute.c nx_secure_tls_1_3_client_handshake.c nx_secure_tls_1_3_crypto_init.c nx_secure_tls_1_3_finished_hash_generate.c nx_secure_tls_1_3_generate_keys.c nx_secure_tls_1_3_server_handshake.c nx_secure_tls_1_3_session_keys_set.c nx_secure_tls_1_3_transcript_hash_save.c nx_secure_tls_active_certificate_set.c nx_secure_tls_allocate_handshake_packet.c nx_secure_tls_check_protocol_version.c nx_secure_tls_ciphersuite_lookup.c nx_secure_tls_client_handshake.c nx_secure_tls_client_psk_set.c nx_secure_tls_ecc_generate_keys.c nx_secure_tls_ecc_initialize.c nx_secure_tls_find_curve_method.c nx_secure_tls_finished_hash_generate.c nx_secure_tls_generate_keys.c nx_secure_tls_generate_premaster_secret.c nx_secure_tls_handshake_hash_init.c nx_secure_tls_handshake_hash_update.c nx_secure_tls_handshake_process.c nx_secure_tls_hash_record.c nx_secure_tls_initialize.c nx_secure_tls_key_material_init.c nx_secure_tls_local_certificate_add.c nx_secure_tls_local_certificate_find.c nx_secure_tls_local_certificate_remove.c nx_secure_tls_map_error_to_alert.c nx_secure_tls_metadata_size_calculate.c nx_secure_tls_newest_supported_version.c nx_secure_tls_packet_allocate.c nx_secure_tls_packet_release.c nx_secure_tls_process_certificate_request.c nx_secure_tls_process_certificate_verify.c nx_secure_tls_process_changecipherspec.c nx_secure_tls_process_client_key_exchange.c nx_secure_tls_process_clienthello.c nx_secure_tls_process_clienthello_extensions.c nx_secure_tls_process_encrypted_extensions.c nx_secure_tls_process_finished.c nx_secure_tls_process_handshake_header.c nx_secure_tls_process_header.c nx_secure_tls_process_newsessionticket.c nx_secure_tls_process_record.c nx_secure_tls_process_remote_certificate.c nx_secure_tls_process_server_key_exchange.c nx_secure_tls_process_serverhello.c nx_secure_tls_process_serverhello_extensions.c nx_secure_tls_protocol_version_get.c nx_secure_tls_psk_add.c nx_secure_tls_psk_binder_generate.c nx_secure_tls_psk_find.c nx_secure_tls_psk_identity_find.c nx_secure_tls_record_hash_calculate.c nx_secure_tls_record_hash_initialize.c nx_secure_tls_record_hash_update.c nx_secure_tls_record_payload_decrypt.c nx_secure_tls_record_payload_encrypt.c nx_secure_tls_remote_certificate_allocate.c nx_secure_tls_remote_certificate_buffer_allocate.c nx_secure_tls_remote_certificate_free.c nx_secure_tls_remote_certificate_free_all.c nx_secure_tls_remote_certificate_verify.c nx_secure_tls_send_alert.c nx_secure_tls_send_certificate.c nx_secure_tls_send_certificate_request.c nx_secure_tls_send_certificate_verify.c nx_secure_tls_send_changecipherspec.c nx_secure_tls_send_client_key_exchange.c nx_secure_tls_send_clienthello.c nx_secure_tls_send_clienthello_extensions.c nx_secure_tls_send_encrypted_extensions.c nx_secure_tls_send_finished.c nx_secure_tls_send_handshake_record.c nx_secure_tls_send_hellorequest.c nx_secure_tls_send_newsessionticket.c nx_secure_tls_send_record.c nx_secure_tls_send_server_key_exchange.c nx_secure_tls_send_serverhello.c nx_secure_tls_send_serverhello_extensions.c nx_secure_tls_server_certificate_add.c nx_secure_tls_server_certificate_find.c nx_secure_tls_server_certificate_remove.c nx_secure_tls_server_handshake.c nx_secure_tls_session_alert_value_get.c nx_secure_tls_session_certificate_callback_set.c nx_secure_tls_session_client_callback_set.c nx_secure_tls_session_client_verify_disable.c nx_secure_tls_session_client_verify_enable.c nx_secure_tls_session_create.c nx_secure_tls_session_create_ext.c nx_secure_tls_session_delete.c nx_secure_tls_session_end.c nx_secure_tls_session_iv_size_get.c nx_secure_tls_session_keys_set.c nx_secure_tls_session_packet_buffer_set.c nx_secure_tls_session_protocol_version_override.c nx_secure_tls_session_receive.c nx_secure_tls_session_receive_records.c nx_secure_tls_session_renegotiate.c nx_secure_tls_session_renegotiate_callback_set.c nx_secure_tls_session_reset.c nx_secure_tls_session_send.c nx_secure_tls_session_server_callback_set.c nx_secure_tls_session_sni_extension_parse.c nx_secure_tls_session_sni_extension_set.c nx_secure_tls_session_start.c nx_secure_tls_session_time_function_set.c nx_secure_tls_session_x509_client_verify_configure.c nx_secure_tls_shutdown.c nx_secure_tls_trusted_certificate_add.c nx_secure_tls_trusted_certificate_remove.c nx_secure_tls_verify_mac.c nx_secure_x509.c nx_secure_x509_asn1_tlv_block_parse.c nx_secure_x509_certificate_chain_verify.c nx_secure_x509_certificate_initialize.c nx_secure_x509_certificate_list_add.c nx_secure_x509_certificate_list_find.c nx_secure_x509_certificate_list_remove.c nx_secure_x509_certificate_revocation_list_parse.c nx_secure_x509_certificate_verify.c nx_secure_x509_common_name_dns_check.c nx_secure_x509_crl_revocation_check.c nx_secure_x509_crl_verify.c nx_secure_x509_distinguished_name_compare.c nx_secure_x509_distinguished_name_parse.c nx_secure_x509_dns_name_initialize.c nx_secure_x509_ec_private_key_parse.c nx_secure_x509_expiration_check.c nx_secure_x509_extended_key_usage_extension_parse.c nx_secure_x509_extension_find.c nx_secure_x509_find_certificate_methods.c nx_secure_x509_free_certificate_get.c nx_secure_x509_key_usage_extension_parse.c nx_secure_x509_local_certificate_find.c nx_secure_x509_local_device_certificate_get.c nx_secure_x509_oid_parse.c nx_secure_x509_pkcs1_rsa_private_key_parse.c nx_secure_x509_pkcs7_decode.c nx_secure_x509_remote_endpoint_certificate_get.c nx_secure_x509_store_certificate_add.c nx_secure_x509_store_certificate_find.c nx_secure_x509_store_certificate_remove.c nx_secure_x509_subject_alt_names_find.c nx_secure_x509_wildcard_compare.c nxe_secure_dtls_client_protocol_version_override.c nxe_secure_dtls_client_session_start.c nxe_secure_dtls_ecc_initialize.c nxe_secure_dtls_packet_allocate.c nxe_secure_dtls_psk_add.c nxe_secure_dtls_server_create.c nxe_secure_dtls_server_delete.c nxe_secure_dtls_server_ecc_initialize.c nxe_secure_dtls_server_local_certificate_add.c nxe_secure_dtls_server_local_certificate_remove.c nxe_secure_dtls_server_notify_set.c nxe_secure_dtls_server_protocol_version_override.c nxe_secure_dtls_server_psk_add.c nxe_secure_dtls_server_session_send.c nxe_secure_dtls_server_session_start.c nxe_secure_dtls_server_start.c nxe_secure_dtls_server_stop.c nxe_secure_dtls_server_trusted_certificate_add.c nxe_secure_dtls_server_trusted_certificate_remove.c nxe_secure_dtls_server_x509_client_verify_configure.c nxe_secure_dtls_server_x509_client_verify_disable.c nxe_secure_dtls_session_client_info_get.c nxe_secure_dtls_session_create.c nxe_secure_dtls_session_delete.c nxe_secure_dtls_session_end.c nxe_secure_dtls_session_local_certificate_add.c nxe_secure_dtls_session_local_certificate_remove.c nxe_secure_dtls_session_receive.c nxe_secure_dtls_session_reset.c nxe_secure_dtls_session_send.c nxe_secure_dtls_session_start.c nxe_secure_dtls_session_trusted_certificate_add.c nxe_secure_dtls_session_trusted_certificate_remove.c nxe_secure_tls_active_certificate_set.c nxe_secure_tls_client_psk_set.c nxe_secure_tls_local_certificate_add.c nxe_secure_tls_local_certificate_find.c nxe_secure_tls_local_certificate_remove.c nxe_secure_tls_metadata_size_calculate.c nxe_secure_tls_packet_allocate.c nxe_secure_tls_psk_add.c nxe_secure_tls_remote_certificate_allocate.c nxe_secure_tls_remote_certificate_buffer_allocate.c nxe_secure_tls_remote_certificate_free_all.c nxe_secure_tls_server_certificate_add.c nxe_secure_tls_server_certificate_find.c nxe_secure_tls_server_certificate_remove.c nxe_secure_tls_session_alert_value_get.c nxe_secure_tls_session_certificate_callback_set.c nxe_secure_tls_session_client_callback_set.c nxe_secure_tls_session_client_verify_disable.c nxe_secure_tls_session_client_verify_enable.c nxe_secure_tls_session_create.c nxe_secure_tls_session_delete.c nxe_secure_tls_session_end.c nxe_secure_tls_session_packet_buffer_set.c nxe_secure_tls_session_protocol_version_override.c nxe_secure_tls_session_receive.c nxe_secure_tls_session_renegotiate.c nxe_secure_tls_session_renegotiate_callback_set.c nxe_secure_tls_session_reset.c nxe_secure_tls_session_send.c nxe_secure_tls_session_server_callback_set.c nxe_secure_tls_session_sni_extension_parse.c nxe_secure_tls_session_sni_extension_set.c nxe_secure_tls_session_start.c nxe_secure_tls_session_time_function_set.c nxe_secure_tls_session_x509_client_verify_configure.c nxe_secure_tls_trusted_certificate_add.c nxe_secure_tls_trusted_certificate_remove.c nxe_secure_x509_certificate_initialize.c nxe_secure_x509_common_name_dns_check.c nxe_secure_x509_crl_revocation_check.c nxe_secure_x509_dns_name_initialize.c nxe_secure_x509_extended_key_usage_extension_parse.c nxe_secure_x509_extension_find.c nxe_secure_x509_key_usage_extension_parse.c
  group lib/stm32cubel4/config
    ../../lib/stm32cubel4/config/: stm32l4xx_hal_conf.h
  group lib/stm32cubel4/drivers
    ../../lib/stm32cubel4/Drivers/BSP/Components/hts221/: hts221.c hts221.h
    ../../lib/stm32cubel4/Drivers/BSP/Components/lis3mdl/: lis3mdl.c lis3mdl.h
    ../../lib/stm32cubel4/Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb.h
    ../../lib/stm32cubel4/Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c lsm6dsl.h
    ../../lib/stm32cubel4/Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01.h stm32l475e_iot01_accelero.c stm32l475e_iot01_accelero.h stm32l475e_iot01_gyro.c stm32l475e_iot01_gyro.h stm32l475e_iot01_hsensor.c stm32l475e_iot01_hsensor.h stm32l475e_iot01_magneto.c stm32l475e_iot01_magneto.h stm32l475e_iot01_psensor.c stm32l475e_iot01_psensor.h stm32l475e_iot01_qspi.c stm32l475e_iot01_qspi.h stm32l475e_iot01_tsensor.c stm32l475e_iot01_tsensor.h
    ../../lib/stm32cubel4/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dsi.c stm32l4xx_hal_exti.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_msp_template.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pka.c stm32l4xx_hal_pssi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_timebase_tim_template.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pka.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
    ../../lib/stm32cubel4/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group lib/threadx
    ../../lib/threadx/: tx_user.h
  group lib/threadx/common/inc
    ../../../../core/lib/threadx/common/inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h
  group lib/threadx/common/src
    ../../../../core/lib/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group lib/threadx/ports/inc
    ../../../../core/lib/threadx/ports/cortex_m4/iar/inc/: tx_port.h
  group lib/threadx/ports/src
    ../../../../core/lib/threadx/ports/cortex_m4/iar/src/: tx_iar.c tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
